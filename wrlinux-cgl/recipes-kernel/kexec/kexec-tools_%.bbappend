RRECOMMENDS_${PN}_wrlinux-cgl = "kexec"
