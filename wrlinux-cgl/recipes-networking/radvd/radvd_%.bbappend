# inhibit radvd auto start that need user to configure it
INHIBIT_UPDATERCD_BBCLASS = "1"
