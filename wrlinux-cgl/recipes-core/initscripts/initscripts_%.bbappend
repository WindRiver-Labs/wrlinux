#
# Copyright (C) 2015 Wind River Systems, Inc.
#
# LOCAL REV: add WR specific scripts
#

# systemd: don't mask /etc/init.d/hostname.sh
MASKED_SCRIPTS_remove_wrlinux-cgl = "hostname"
