RDEPENDS_${PN} += "\
	mcstrans \
	policycoreutils \
"
