
DEPENDS += "crash-native"
