# wrlinux-image-glibc-cgl is depreated, use wrlinux-image-cgl instead

inherit deprecate
ALTERNATIVE_NEW_RECIPE = "wrlinux-image-cgl"
require wrlinux-image-cgl.bb
