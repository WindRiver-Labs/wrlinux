# This file is generated automatically by wry
KBD_INC_WRLINUX = ""
KBD_INC_WRLINUX_osv-wrlinux = "kbd_wrlinux.inc"
require ${KBD_INC_WRLINUX}
