PACKAGE_INDEX_WRL ?= ""
PACKAGE_INDEX_WRL_osv-wrlinux ?= "package-index-wrl.inc"

require ${PACKAGE_INDEX_WRL}
