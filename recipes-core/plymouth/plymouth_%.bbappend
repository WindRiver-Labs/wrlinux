# This file is generated automatically by wry
PLYMOUTH_INC_WRLINUX = ""
PLYMOUTH_INC_WRLINUX_osv-wrlinux = "plymouth_wrlinux.inc"
require ${PLYMOUTH_INC_WRLINUX}
