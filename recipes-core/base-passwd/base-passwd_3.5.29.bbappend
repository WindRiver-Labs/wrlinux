#
# Copyright (C) 2012, 2016 Wind River Systems, Inc.
#
# Remove this bbappend after the recipe is upgraded.
#
#
PR .= ".1"
