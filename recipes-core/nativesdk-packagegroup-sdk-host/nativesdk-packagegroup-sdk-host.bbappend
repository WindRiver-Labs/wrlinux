RDEPENDS_${PN} += "\
    nativesdk-mtools \
    nativesdk-syslinux \
    "