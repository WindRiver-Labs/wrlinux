# This file is generated automatically by wry
GLIBC_INC_WRLINUX = ""
GLIBC_INC_WRLINUX_osv-wrlinux = "glibc_wrlinux.inc"
require ${GLIBC_INC_WRLINUX}
