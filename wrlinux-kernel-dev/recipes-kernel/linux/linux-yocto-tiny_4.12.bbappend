require wkd-linux-yocto_4.12.inc
