# This file is generated automatically by wry
LTP_INC_WRLINUX = ""
LTP_INC_WRLINUX_osv-wrlinux = "ltp_wrlinux.inc"
require ${LTP_INC_WRLINUX}
