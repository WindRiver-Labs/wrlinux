# This file is generated automatically by wry
PACKAGEGROUP_BUSYBOX_REPLACEMENT_INC_WRLINUX = ""
PACKAGEGROUP_BUSYBOX_REPLACEMENT_INC_WRLINUX_osv-wrlinux = "packagegroup-core-base-utils_wrlinux.inc"
require ${PACKAGEGROUP_BUSYBOX_REPLACEMENT_INC_WRLINUX}
