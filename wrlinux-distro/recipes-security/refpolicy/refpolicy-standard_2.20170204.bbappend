#
# Copyright (C) 2012 Wind River Systems, Inc.
#

POLICY_NAME = "wr-standard"

include refpolicy_wr.inc
