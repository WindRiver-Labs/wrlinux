#
# Copyright (C) 2012, 2019 Wind River Systems, Inc.
#

POLICY_NAME = "wr-mls"

include refpolicy_wr.inc
