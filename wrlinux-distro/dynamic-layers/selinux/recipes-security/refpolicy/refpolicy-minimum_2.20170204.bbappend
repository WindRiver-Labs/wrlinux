#
# Copyright (C) 2012, 2017 Wind River Systems, Inc.
#

POLICY_NAME = "wr-minimum"

include refpolicy-minimum_wr.inc
