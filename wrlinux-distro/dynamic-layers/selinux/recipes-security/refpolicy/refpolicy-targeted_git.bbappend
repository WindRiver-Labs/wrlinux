#
# Copyright (C) 2012, 2019 Wind River Systems, Inc.
#

POLICY_NAME = "wr-targeted"

include refpolicy-targeted_wr.inc
