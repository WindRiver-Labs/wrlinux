# This file is generated automatically by wry
LIBPAM_INC_WRLINUX = ""
LIBPAM_INC_WRLINUX_osv-wrlinux = "libpam_wrlinux.inc"
require ${LIBPAM_INC_WRLINUX}
