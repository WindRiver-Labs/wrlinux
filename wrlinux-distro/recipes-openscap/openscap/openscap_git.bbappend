SRCREV = "c70bc47449398dc31b66cb00ca00c820a369c4e3"
SRC_URI = "git://github.com/OpenSCAP/openscap.git;branch=maint-1.3 \
          "
PV = "1.3.1+git${SRCPV}"
