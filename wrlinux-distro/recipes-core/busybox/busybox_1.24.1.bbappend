#
# Copyright (C) 2013 -2016 Wind River Systems, Inc.
#

# For glibc-tiny
FILESEXTRAPATHS_prepend_wrlinux-tiny := "${THISDIR}/${P}/wrlinux-tiny:"
