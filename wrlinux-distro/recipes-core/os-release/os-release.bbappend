# This file is generated automatically by wry
OS_RELEAS_INC_WRLINUX = ""
OS_RELEAS_INC_WRLINUX_osv-wrlinux = "os-releas_wrlinux.inc"
require ${OS_RELEAS_INC_WRLINUX}
