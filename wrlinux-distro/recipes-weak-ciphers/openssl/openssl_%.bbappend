# This file is generated automatically by wry
OPENSSL_INC_WRLINUX = ""
OPENSSL_INC_WRLINUX_osv-wrlinux = "openssl_wrlinux.inc"
require ${OPENSSL_INC_WRLINUX}
