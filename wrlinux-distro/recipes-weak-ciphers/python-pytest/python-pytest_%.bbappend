# This file is generated automatically by wry
PYTHON_PYTEST_INC_WRLINUX = ""
PYTHON_PYTEST_INC_WRLINUX_osv-wrlinux = "python-pytest_wrlinux.inc"
require ${PYTHON_PYTEST_INC_WRLINUX}
