# This file is generated automatically by wry
PYTHON_REQUESTS_INC_WRLINUX = ""
PYTHON_REQUESTS_INC_WRLINUX_osv-wrlinux = "python-requests_wrlinux.inc"
require ${PYTHON_REQUESTS_INC_WRLINUX}
