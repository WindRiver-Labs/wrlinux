# This file is generated automatically by wry
PYTHON3_PYTEST_INC_WRLINUX = ""
PYTHON3_PYTEST_INC_WRLINUX_osv-wrlinux = "python3-pytest_wrlinux.inc"
require ${PYTHON3_PYTEST_INC_WRLINUX}
