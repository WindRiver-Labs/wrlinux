# This file is generated automatically by wry
PYTHON_URLLIB3_INC_WRLINUX = ""
PYTHON_URLLIB3_INC_WRLINUX_osv-wrlinux = "python-urllib3_wrlinux.inc"
require ${PYTHON_URLLIB3_INC_WRLINUX}
