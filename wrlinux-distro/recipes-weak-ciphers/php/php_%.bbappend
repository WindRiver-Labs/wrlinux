# This file is generated automatically by wry
PHP_INC_WRLINUX = ""
PHP_INC_WRLINUX_osv-wrlinux = "php_wrlinux.inc"
require ${PHP_INC_WRLINUX}
