# This file is generated automatically by wry
PYTHON3_PYOPENSSL_INC_WRLINUX = ""
PYTHON3_PYOPENSSL_INC_WRLINUX_osv-wrlinux = "python3-pyopenssl_wrlinux.inc"
require ${PYTHON3_PYOPENSSL_INC_WRLINUX}
