# This file is generated automatically by wry
PYTHON3_CRYPTOGRAPHY_VECTORS_INC_WRLINUX = ""
PYTHON3_CRYPTOGRAPHY_VECTORS_INC_WRLINUX_osv-wrlinux = "python3-cryptography-vectors_wrlinux.inc"
require ${PYTHON3_CRYPTOGRAPHY_VECTORS_INC_WRLINUX}
