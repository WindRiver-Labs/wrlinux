# This file is generated automatically by wry
OPENSSH_INC_WRLINUX = ""
OPENSSH_INC_WRLINUX_osv-wrlinux = "openssh_wrlinux.inc"
require ${OPENSSH_INC_WRLINUX}
