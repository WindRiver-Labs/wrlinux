# This file is generated automatically by wry
PYTHON_CRYPTOGRAPHY_INC_WRLINUX = ""
PYTHON_CRYPTOGRAPHY_INC_WRLINUX_osv-wrlinux = "python-cryptography_wrlinux.inc"
require ${PYTHON_CRYPTOGRAPHY_INC_WRLINUX}
