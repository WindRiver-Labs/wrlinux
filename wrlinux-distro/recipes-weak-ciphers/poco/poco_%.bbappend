# This file is generated automatically by wry
POCO_INC_WRLINUX = ""
POCO_INC_WRLINUX_osv-wrlinux = "poco_wrlinux.inc"
require ${POCO_INC_WRLINUX}
