# This file is generated automatically by wry
PYTHON3_ATTRS_INC_WRLINUX = ""
PYTHON3_ATTRS_INC_WRLINUX_osv-wrlinux = "python3-attrs_wrlinux.inc"
require ${PYTHON3_ATTRS_INC_WRLINUX}
