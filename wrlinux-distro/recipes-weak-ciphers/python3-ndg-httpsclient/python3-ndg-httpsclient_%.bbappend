# This file is generated automatically by wry
PYTHON3_NDG_HTTPSCLIENT_INC_WRLINUX = ""
PYTHON3_NDG_HTTPSCLIENT_INC_WRLINUX_osv-wrlinux = "python3-ndg-httpsclient_wrlinux.inc"
require ${PYTHON3_NDG_HTTPSCLIENT_INC_WRLINUX}
