# This file is generated automatically by wry
DOVECOT_INC_WRLINUX = ""
DOVECOT_INC_WRLINUX_osv-wrlinux = "dovecot_wrlinux.inc"
require ${DOVECOT_INC_WRLINUX}
