# This file is generated automatically by wry
CFENGINE_INC_WRLINUX = ""
CFENGINE_INC_WRLINUX_osv-wrlinux = "cfengine_wrlinux.inc"
require ${CFENGINE_INC_WRLINUX}
