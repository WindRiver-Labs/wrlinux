# This file is generated automatically by wry
PYTHON3_REQUESTS_INC_WRLINUX = ""
PYTHON3_REQUESTS_INC_WRLINUX_osv-wrlinux = "python3-requests_wrlinux.inc"
require ${PYTHON3_REQUESTS_INC_WRLINUX}
