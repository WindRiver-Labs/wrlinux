# This file is generated automatically by wry
PYTHON_ATTRS_INC_WRLINUX = ""
PYTHON_ATTRS_INC_WRLINUX_osv-wrlinux = "python-attrs_wrlinux.inc"
require ${PYTHON_ATTRS_INC_WRLINUX}
