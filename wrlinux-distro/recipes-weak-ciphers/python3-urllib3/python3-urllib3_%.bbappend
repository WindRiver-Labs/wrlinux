# This file is generated automatically by wry
PYTHON3_URLLIB3_INC_WRLINUX = ""
PYTHON3_URLLIB3_INC_WRLINUX_osv-wrlinux = "python3-urllib3_wrlinux.inc"
require ${PYTHON3_URLLIB3_INC_WRLINUX}
