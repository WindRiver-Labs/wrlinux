# This file is generated automatically by wry
PYTHON_NDG_HTTPSCLIENT_INC_WRLINUX = ""
PYTHON_NDG_HTTPSCLIENT_INC_WRLINUX_osv-wrlinux = "python-ndg-httpsclient_wrlinux.inc"
require ${PYTHON_NDG_HTTPSCLIENT_INC_WRLINUX}
