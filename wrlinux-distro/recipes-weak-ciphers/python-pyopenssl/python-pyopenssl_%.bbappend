# This file is generated automatically by wry
PYTHON_PYOPENSSL_INC_WRLINUX = ""
PYTHON_PYOPENSSL_INC_WRLINUX_osv-wrlinux = "python-pyopenssl_wrlinux.inc"
require ${PYTHON_PYOPENSSL_INC_WRLINUX}
