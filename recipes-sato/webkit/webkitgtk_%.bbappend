# This file is generated automatically by wry
WEBKITGTK_INC_WRLINUX = ""
WEBKITGTK_INC_WRLINUX_osv-wrlinux = "webkitgtk_wrlinux.inc"
require ${WEBKITGTK_INC_WRLINUX}
