OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "libvirt-4.3.%.inc"

require ${OVP_INCLUDE}
