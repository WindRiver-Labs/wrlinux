OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "libvirt-4.5.%.inc"

require ${OVP_INCLUDE}
