OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "libvirt-1.3.%.inc"

require ${OVP_INCLUDE}
