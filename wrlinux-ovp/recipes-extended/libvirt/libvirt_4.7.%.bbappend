OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "libvirt-4.7.%.inc"

require ${OVP_INCLUDE}
