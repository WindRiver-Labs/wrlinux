OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "qemu-ovp-2.10.0.inc"

require ${OVP_INCLUDE}
