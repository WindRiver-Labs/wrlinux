OVP_INCLUDE = "qemu-ovp-3.0.0.inc"
OVP_INCLUDE_wrlinux-ovp = "qemu-ovp-3.0.0.inc"

require ${OVP_INCLUDE}
