OVP_INCLUDE = ""
OVP_INCLUDE_wrlinux-ovp = "qemu-ovp.inc"

require ${OVP_INCLUDE}
