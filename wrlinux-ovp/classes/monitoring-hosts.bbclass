# IP address of server which proxy should connect to
MONITORING_PROXY_SERVER_IP ??= "192.168.7.2"

# IP address of server which agent should connect to
MONITORING_AGENT_SERVER_IP ??= "192.168.7.4"

MONITORING_PROXY_NAME ??= "proxy"
MONITORING_AGENT_NAME ??= "agent"
