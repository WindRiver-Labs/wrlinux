SRC_URI = "file://0001-Lxc-for-wrlinux-add-WR-local-template.patch \
	"
