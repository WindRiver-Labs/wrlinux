# Remove it after the recipe is upgraded
PR = "r500"
