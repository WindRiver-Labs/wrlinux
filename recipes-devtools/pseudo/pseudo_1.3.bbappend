DEPENDS_virtclass-native = "sqlite3-native git-native"
