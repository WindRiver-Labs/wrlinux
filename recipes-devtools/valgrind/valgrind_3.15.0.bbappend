# This file is generated automatically by wry
VALGRIND_INC_WRLINUX = ""
VALGRIND_INC_WRLINUX_osv-wrlinux = "valgrind_wrlinux.inc"
require ${VALGRIND_INC_WRLINUX}
