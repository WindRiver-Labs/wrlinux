FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-as-Print-more-info-when-input-and-output-files-are-s.patch"
