# Disable BBCLASSEXTEND nativesdk
BBCLASSEXTEND = ""
