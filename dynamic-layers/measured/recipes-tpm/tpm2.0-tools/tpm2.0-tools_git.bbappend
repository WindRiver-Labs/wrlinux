PNBLACKLIST[tpm2.0-tools] = "Requires download access"
PV = "git"
SRCREV = "1"
