PNBLACKLIST[tpm2.0-tss] = "Requires download access"
PV = "git"
SRCREV = "1"
