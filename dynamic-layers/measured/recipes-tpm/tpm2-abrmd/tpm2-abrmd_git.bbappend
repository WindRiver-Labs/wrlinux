PNBLACKLIST[tpm2-abrmd] = "Requires download access"
PV = "git"
SRCREV = "1"
