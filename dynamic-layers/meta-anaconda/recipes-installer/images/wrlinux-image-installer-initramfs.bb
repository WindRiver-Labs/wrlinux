#
# Copyright (C) 2017-2018 Wind River Systems, Inc.
#
require recipes-installer/images/core-image-anaconda-initramfs.bb
