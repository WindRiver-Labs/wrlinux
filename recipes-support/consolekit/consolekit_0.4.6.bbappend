# Remove it when consolekit is upgraded.
PR = "r500"
