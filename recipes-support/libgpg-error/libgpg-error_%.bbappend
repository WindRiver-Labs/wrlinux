#
# Copyright (C) 2016 Wind River Systems, Inc.
#

BBCLASSEXTEND += "nativesdk"
