# This file is generated automatically by wry
PTEST_RUNNER_INC_WRLINUX = ""
PTEST_RUNNER_INC_WRLINUX_osv-wrlinux = "ptest-runner_wrlinux.inc"
require ${PTEST_RUNNER_INC_WRLINUX}
