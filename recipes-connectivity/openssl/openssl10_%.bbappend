PROVIDES += "openssl"

RPROVIDES_${PN} += "openssl"
RPROVIDES_libcrypto10 += "libcrypto"
RPROVIDES_libssl10 += "libssl"
RPROVIDES_openssl10-conf += "openssl-conf"
RPROVIDES_${PN}-engines += "openssl-engines"
RPROVIDES_${PN}-misc += "openssl-misc"
RPROVIDES_${PN}-dev += "openssl-dev"
RPROVIDES_${PN}-dbg += "openssl-dbg"
RPROVIDES_${PN}-doc += "openssl-doc"
RPROVIDES_${PN}-staticdev += "openssl-staticdev"
RPROVIDES_${PN}-locale += "openssl-locale"

