# This file is generated automatically by wry
DHCPCD_INC_WRLINUX = ""
DHCPCD_INC_WRLINUX_osv-wrlinux = "dhcpcd_wrlinux.inc"
require ${DHCPCD_INC_WRLINUX}
