# This file is generated automatically by wry
DHCP_INC_WRLINUX = ""
DHCP_INC_WRLINUX_osv-wrlinux = "dhcp_wrlinux.inc"
require ${DHCP_INC_WRLINUX}
