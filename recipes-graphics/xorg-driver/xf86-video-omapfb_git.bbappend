# Remove it after the recipe is updated
PR = "r500"
