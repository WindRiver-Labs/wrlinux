FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-scripts-Print-more-info-for-debugging-gcc-goto-error.patch"
