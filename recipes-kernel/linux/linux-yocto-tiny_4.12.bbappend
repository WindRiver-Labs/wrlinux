require linux-yocto-wrlinux.inc
include srcrev.inc
require extra-kernel-src.inc

KBRANCH_qemux86-64 = "standard/tiny/wr-base"
KBRANCH_qemux86 = "standard/tiny/wr-base"
