PR = "r500"

COMPATIBLE_HOST = "(i.86|x86_64).*-linux"
