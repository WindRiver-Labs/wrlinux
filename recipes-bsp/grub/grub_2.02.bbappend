# Add the ability to create a grub-native
BBCLASSEXTEND_append = " native"
